../../../bitbake/classes/base.bbclass