# Copyright (C) 2019 qian.hao <qian.hao@kk.jp.panasonic.com>
# Released under the MIT license (see COPYING.MIT for the terms)

SUMMARY = "This is a template test recipe for all kinds of testing"

do_build() {
    echo "test"
}
